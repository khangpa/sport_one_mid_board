# IAR project sport_one_middle_board.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F102C6 ST STM32F102C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; DEBUG
  ICCARM.CCIncludePath2: ..\App; ..\App\inc; ..\Driver_St\inc; ..\Driver_User\inc; ..\Startup; ..\Utility; ..\Common; ..\Mid\inc; ..\Mid\src; ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\CMSIS\CM3\CoreSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sport_one_middle_board.srec
  ILINK.IlinkOutputFile: sport_one_middle_board.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: board.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group CMSIS/Device
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group CMSIS/Device/startup
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group Common
    ../Common/: common.c common.h
  group Driver_St/inc
    ../Driver_St/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Driver_St/src
    ../Driver_St/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Mid/inc
    ../Mid/inc/: android.h clock.h dfplayer.h keypad.h lcd.h power_communicate.h screen.h systick.h timer3.h uart.h
  group Mid/src
    ../Mid/src/: android.c clock.c keypad.c lcd.c power_communicate.c screen.c systick.c timer3.c uart.c
  group Utility
    ../Utility/: queue.c queue.h xor.c xor.h
